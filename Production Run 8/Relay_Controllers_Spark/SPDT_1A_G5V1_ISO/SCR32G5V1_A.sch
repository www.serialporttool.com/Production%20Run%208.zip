# EAGLE board SCR32G5V1_A (EAGLE 7.0.0), part 2 of 2
## Text on the board
tNames: NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | 8 | 5 | 4 | 1 | 8 | 5 | 4 | 1 | NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | NC | COM | NO | SCR32G5V1 | Bank 4 | Bank 2 | MCP23017 | REV.A | Address: | A1 | A2 | GND | +5V | SC | SDA | SCL | I2C OUT | 2016 ControlEverything.com | Address A0=0 | Address A0=1 | Bank 3 | Bank 1 | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC | 8 | 5 | 4 | 1 | 8 | 5 | 4 | 1 | 12V DC / Power / Supply | 12V DC / Power / Supply | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC | NO | COM | NC